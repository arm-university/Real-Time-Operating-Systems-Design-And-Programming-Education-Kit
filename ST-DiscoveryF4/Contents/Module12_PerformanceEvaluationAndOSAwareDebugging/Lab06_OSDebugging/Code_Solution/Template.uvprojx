# Keil uVision project Template.uvprojx, settings and files
target STM32F4Discovery (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.5.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(168000000) ELITTLE
  output: Template
  c flags: Optim=1 OneElfS=1
  c define: STM32F40XX
  c include: C:\Keil_v5\ARM\RV31\INC;.\drivers
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group RTX
    ./: RTX_Conf_CM.c
  group drivers
    ./drivers/: adc.c adc.h gpio.c gpio.h platform.h setup.c setup.h
  group src
    ./: main.c
software components: CMSIS:CORE 4.1.0, Device:STM32Cube Framework:Classic 1.3.1, Device:STM32Cube HAL:Common 1.3.1, Device:STM32Cube HAL:Cortex 1.3.1, Device:STM32Cube HAL:GPIO 1.3.1, Device:STM32Cube HAL:PWR 1.3.1, Device:STM32Cube HAL:RCC 1.3.1, Device:Startup 2.3.1
